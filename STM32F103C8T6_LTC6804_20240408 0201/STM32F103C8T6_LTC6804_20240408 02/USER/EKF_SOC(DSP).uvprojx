# Keil uVision project EKF_SOC(DSP).uvprojx, settings and files
target PWM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,ARM_MATH_CM3
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\APP\motor;..\HARDWARE\LCD;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\APP\drive_car;..\HARDWARE\LTC6804;..\HARDWARE\SYS_CLK;..\HARDWARE\LCD;..\HARDWARE\RTC;..\APP\MATH;..\HARDWARE\IO_CTRL;..\HARDWARE\WDG;..\HARDWARE\BEEP;..\HARDWARE\CAN;..\HARDWARE\ADC;..\DSPlib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LTC6804/: LTC6804-1.c
    ./: Simulated_SPI.c simulated_SPI.h 24c02.c 24c02.h LTC1380.c LTC1380.h
    ../HARDWARE/SYS_CLK/: bsp_clkconfig.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/IO_CTRL/: IO_CTRL.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/ADC/: adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_iwdg.c stm32f10x_can.c stm32f10x_adc.c
  group README
    ../: README.TXT
  group APP
    ./: temp.c temp.h user_get.c user_get.h EKF_SOC.c EKF_SOC.h
    ../APP/MATH/: kalman.c filter.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
